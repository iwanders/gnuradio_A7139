options:
  parameters:
    generate_options: qt_gui
    id: record_playback
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_file_meta_source_0
  id: blocks_file_meta_source
  parameters:
    detached: 'False'
    file: /tmp/capture_query.grcbin
    hdr_file: /tmp/capture_query.grcbin
    repeat: 'True'
    type: complex
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '443920000'
    fftsize: '32768'
    rate: '100'
    type: complex
  states: {}

connections:
- [blocks_file_meta_source_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
