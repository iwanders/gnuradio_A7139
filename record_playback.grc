options:
  parameters:
    generate_options: qt_gui
    id: record_playback
    output_language: python
    title: Analysis
  states: {}

blocks:
- name: bandpass_filter_width
  id: variable
  parameters:
    value: 60e3
  states: {}
- name: expected_ted_gain
  id: variable_qtgui_range
  parameters:
    start: '0.01'
    step: '0.01'
    stop: '1.0'
    value: '0.93'
  states: {}
- name: fsk_deviation_hz
  id: variable
  parameters:
    value: 20e3
  states: {}
- name: packet_len
  id: variable
  parameters:
    value: '5'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2048000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: samp_rate / symbol_rate
  states: {}
- name: squelch_alpha
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.0000001'
    stop: '1.0'
    value: '0.74'
  states: {}
- name: squelch_threshold_db
  id: variable_qtgui_range
  parameters:
    start: '-100'
    step: '1'
    stop: '100'
    value: '-3'
  states: {}
- name: symbol_rate
  id: variable
  parameters:
    value: '10000'
  states: {}
- name: sync_bw
  id: variable_qtgui_range
  parameters:
    start: '0.01'
    step: '0.01'
    stop: '1.0'
    value: '0.05'
  states: {}
- name: analog_quadrature_demod_cf_1
  id: analog_quadrature_demod_cf
  parameters:
    gain: samp_rate/(2*math.pi*fsk_deviation_hz)
  states: {}
- name: analog_simple_squelch_cc_1
  id: analog_simple_squelch_cc
  parameters:
    alpha: squelch_alpha
    threshold: squelch_threshold_db
  states: {}
- name: blocks_file_meta_source_0
  id: blocks_file_meta_source
  parameters:
    detached: 'False'
    file: /tmp/capture_query.grcbin
    hdr_file: /tmp/capture_query.grcbin
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: int(samp_rate*1.0)
    type: complex
  states: {state: bypassed}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters:
    log_level: trace
  states: {state: disabled}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: int(sps)
    max_iter: '4000'
    scale: '0.1'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '100'
    type: float
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_LSB_FIRST
    k: '1'
    l: '8'
  states: {state: bypassed}
- name: blocks_repack_bits_bb_0_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_LSB_FIRST
    k: '1'
    l: '8'
  states: {}
- name: blocks_skiphead_0
  id: blocks_skiphead
  parameters:
    num_items: int(samp_rate*1.5)
    type: complex
  states: {state: bypassed}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    limit: time
    maximum: '1'
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_uchar_to_float_0_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_binary_slicer_fb_0_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_correlate_access_code_tag_xx_1
  id: digital_correlate_access_code_tag_xx
  parameters:
    access_code: '101010101010'
    tagname: zzz
    threshold: '0'
    type: byte
  states: {state: disabled}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.01'
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: expected_ted_gain
    ted_type: digital.TED_EARLY_LATE
    type: ff
  states: {state: disabled}
- name: digital_symbol_sync_xx_1
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: sync_bw
    max_dev: '5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: expected_ted_gain
    ted_type: digital.TED_EARLY_LATE
    type: ff
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      """
      https://www.gnuradio.org/doc/doxygen-3.7/page_python_blocks.html
      numpy.int8
      numpy.int16
      numpy.int32
      numpy.float32
      numpy.float64
      """

      class blkz(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, storage_file="/tmp/our_bits.bin"):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='WriteBitsToFile',   # will show up in GRC
                  in_sig=[np.byte],
                  out_sig=[]
              )

              self.storage_file = storage_file

          def work(self, input_items, output_items):
              # print(type(input_items))
              # print(input_items)
              self.f.write(input_items[0].tobytes())
              return 0
              """example: multiply with constant"""
              output_items[0][:] = input_items[0] * self.example_param
              return 0


          def start(self):
              self.f = open(self.storage_file, "wb")

          def stop(self):
              self.f.close()
              self.f = None
    storage_file: '''/tmp/our_bits.bin'''
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: 434100000 + 0.07e6
    decim: '1'
    samp_rate: samp_rate
    taps: firdes.complex_band_pass(1.0, samp_rate, fsk_deviation_hz/2 - bandpass_filter_width, fsk_deviation_hz/2 + bandpass_filter_width, bandpass_filter_width)
    type: ccc
  states: {}
- name: ival_decimator_0
  id: ival_decimator
  parameters:
    decimation: '10000'
  states: {}
- name: network_udp_sink_0
  id: network_udp_sink
  parameters:
    addr: 127.0.0.1
    header: '0'
    payloadsize: '8'
    port: '2003'
    send_eof: 'False'
    type: byte
  states: {}
- name: pdu_tagged_stream_to_pdu_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: zzz
    type: byte
  states: {state: disabled}
- name: pdu_tags_to_pdu_x_0
  id: pdu_tags_to_pdu_x
  parameters:
    end_tag: EOB
    start_tag: SOB
    type: c
  states: {state: disabled}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '443920000'
    fftsize: '32768'
    rate: '60'
    type: complex
  states: {}
- name: qtgui_sink_x_1
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '32768'
    rate: '60'
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    label1: BinarySliced
    label2: QuadDemod
    marker1: '1'
    nconnections: '2'
    size: 1024*100
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: float
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    name: '"rootraised"'
    size: 1024*100
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: float
  states: {}
- name: qtgui_time_sink_x_2
  id: qtgui_time_sink_x
  parameters:
    label1: symbols
    label2: error
    label3: bits
    marker1: '0'
    marker3: '0'
    name: '"zzzz"'
    nconnections: '3'
    size: '1024'
    srate: symbol_rate * 2
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: float
    update_time: '0.01'
  states: {}
- name: qtgui_time_sink_x_2_0
  id: qtgui_time_sink_x
  parameters:
    label1: error
    marker1: '0'
    name: '"error"'
    size: '1024'
    srate: symbol_rate * 2
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: float
    update_time: '0.01'
  states: {}
- name: qtgui_time_sink_x_3
  id: qtgui_time_sink_x
  parameters:
    label1: inst
    label2: avg
    name: '"tinst/avg"'
    nconnections: '2'
    size: 1024 * 10
    srate: symbol_rate * 2
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: float
    ymax: sps + 0.1 * sps
    ymin: sps - 0.1 * sps
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '0.98'
    decim: '1'
    gain: '0.5'
    ntaps: '512'
    samp_rate: samp_rate / 4
    sym_rate: symbol_rate
    type: fir_filter_fff
  states: {}

connections:
- [analog_quadrature_demod_cf_1, '0', digital_binary_slicer_fb_0, '0']
- [analog_quadrature_demod_cf_1, '0', qtgui_time_sink_x_0, '1']
- [analog_quadrature_demod_cf_1, '0', root_raised_cosine_filter_0, '0']
- [analog_simple_squelch_cc_1, '0', analog_quadrature_demod_cf_1, '0']
- [analog_simple_squelch_cc_1, '0', qtgui_sink_x_1, '0']
- [blocks_file_meta_source_0, '0', blocks_skiphead_0, '0']
- [blocks_head_0, '0', blocks_throttle2_0, '0']
- [blocks_moving_average_xx_0, '0', digital_symbol_sync_xx_1, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_time_sink_x_2, '2']
- [blocks_repack_bits_bb_0, '0', network_udp_sink_0, '0']
- [blocks_repack_bits_bb_0_0, '0', epy_block_0, '0']
- [blocks_skiphead_0, '0', blocks_head_0, '0']
- [blocks_throttle2_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [blocks_throttle2_0, '0', qtgui_sink_x_0, '0']
- [blocks_uchar_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_uchar_to_float_0_0, '0', blocks_multiply_const_vxx_0, '0']
- [digital_binary_slicer_fb_0, '0', blocks_uchar_to_float_0, '0']
- [digital_binary_slicer_fb_0, '0', ival_decimator_0, '0']
- [digital_binary_slicer_fb_0_0, '0', blocks_repack_bits_bb_0, '0']
- [digital_binary_slicer_fb_0_0, '0', blocks_uchar_to_float_0_0, '0']
- [digital_binary_slicer_fb_0_0, '0', digital_correlate_access_code_tag_xx_1, '0']
- [digital_correlate_access_code_tag_xx_1, '0', blocks_repack_bits_bb_0, '0']
- [digital_correlate_access_code_tag_xx_1, '0', blocks_uchar_to_float_0_0, '0']
- [digital_correlate_access_code_tag_xx_1, '0', pdu_tagged_stream_to_pdu_0, '0']
- [digital_symbol_sync_xx_1, '0', blocks_null_sink_0, '0']
- [digital_symbol_sync_xx_1, '0', digital_binary_slicer_fb_0_0, '0']
- [digital_symbol_sync_xx_1, '0', qtgui_time_sink_x_2, '0']
- [digital_symbol_sync_xx_1, '0', qtgui_time_sink_x_2, '1']
- [digital_symbol_sync_xx_1, '1', qtgui_time_sink_x_2_0, '0']
- [digital_symbol_sync_xx_1, '2', qtgui_time_sink_x_3, '0']
- [digital_symbol_sync_xx_1, '3', qtgui_time_sink_x_3, '1']
- [freq_xlating_fir_filter_xxx_0, '0', analog_simple_squelch_cc_1, '0']
- [ival_decimator_0, '0', blocks_repack_bits_bb_0_0, '0']
- [pdu_tagged_stream_to_pdu_0, pdus, blocks_message_debug_0, log]
- [pdu_tagged_stream_to_pdu_0, pdus, blocks_message_debug_0, print]
- [root_raised_cosine_filter_0, '0', blocks_moving_average_xx_0, '0']
- [root_raised_cosine_filter_0, '0', digital_symbol_sync_xx_0, '0']
- [root_raised_cosine_filter_0, '0', qtgui_time_sink_x_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
